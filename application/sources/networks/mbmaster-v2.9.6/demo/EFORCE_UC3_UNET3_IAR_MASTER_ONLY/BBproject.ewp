# IAR project BBproject.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe170
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: BBproject.out
  ILINK.IlinkIcfFile: Source\MB9BF_ram.icf
  ILINK.IlinkAdditionalLibs: Source\uC3cortexm3l.a; Source\uNet3cortexm3l.a; Source\uC3Tcortexm3l.a
  ILINK.IlinkProgramEntryLabel: ResetHandler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: Source; Source/port; ../../mbmaster/include
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: BBproject.srec
  group (top)
    Source/: DDR_COM.c DDR_M3_FM3_ETH.c DDR_M_SysTick.c DDR_MB9BF_UART.c devdrv.c dhcp_client.c dns_client.c excp.s79 ftp_server.c http_server.c hw_init.c kernel_cfg.c main.c modbus.c modbus.h net_cfg.c net_strlib.c ping_client.c prst.s79 sntp_client.c vect.s79 wfi.s79
  group MODBUS
    ../../mbmaster/: mbm.c
    ../../mbmaster/ascii/: mbmascii.c
    ../../mbmaster/rtu/: mbmcrc.c mbmrtu.c
    ../../mbmaster/functions/: mbmfunccoils.c mbmfuncdisc.c mbmfuncfiles.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c mbmfuncslaveid.c
    ../../mbmaster/tcp/: mbmtcp.c
    ../../mbmaster/udp/: mbmudp.c
    ../../mbmaster/common/: mbutils.c
  group MODBUS Port
    Source/port/: mbport.h mbportevent.c mbportother.c mbporttcp.c mbporttimer.c mbsconfig.h
