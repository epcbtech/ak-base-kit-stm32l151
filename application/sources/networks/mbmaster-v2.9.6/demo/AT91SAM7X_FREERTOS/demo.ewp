# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: SAM7_IAR=1
  ICCARM.CCIncludePath2: IAR; FreeRTOS\include; FreeRTOS\portable\IAR\AtmelSAM7S64; port; ..\..\mbmaster\include; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: IAR; FreeRTOS\portable\IAR\AtmelSAM7S64
  OBJCOPY.OOCOutputFile: demo.srec
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: IAR\sam7x256-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: demo.c FreeRTOSConfig.h
  group FreeRTOS
    FreeRTOS/: croutine.c list.c queue.c tasks.c
    FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
    FreeRTOS/portable/MemMang/: heap_2.c
    FreeRTOS/portable/IAR/AtmelSAM7S64/: ISR_Support.h port.c portasm.s79 portmacro.h
  group IAR
    IAR/: AT91SAM7X256.h AT91SAM7X256_inc.h Board.h Cstartup.s Cstartup_SAM7.c dbgu.c lib_AT91SAM7X256.h
  group MODBUS
    ../../mbmaster/: mbm.c
    ../../mbmaster/ascii/: mbmascii.c mbmascii.h
    ../../mbmaster/rtu/: mbmcrc.c mbmcrc.h mbmrtu.c mbmrtu.h
    ../../mbmaster/functions/: mbmfunccoils.c mbmfuncdisc.c mbmfuncholding.c mbmfuncinput.c
    ../../mbmaster/common/: mbutils.c
  group MODBUS Port
    port/: mbmconfig.h mbport.h mbportevent.c mbportother.c mbportserial.c mbportserial_IAR.s79 mbporttimer.c
    IAR/: sam7x256-flash.icf
