# IAR project demo-tcp.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: UART_BUFFERED; PART_LM3S6965; WITH_LWIP
  ICCARM.CCIncludePath2: $PROJ_DIR$; lwip\src\include; lwip\src\include\ipv4; lwip\ports\stellaris\include; port; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM3; ..\..\mbmaster\include; Stellarisware
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: IARAS
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: demo-tcp.srec
  ILINK.IlinkOutputFile: demo-tcp.out
  ILINK.IlinkIcfFile: ewarm\interrupts.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: demo-tcp.c
    ewarm/: startup_ewarm.c
  group DriverLib
    Stellarisware/driverlib/ewarm/: driverlib.a
    Stellarisware/utils/: uartstdio.c
  group FreeRTOS
    FreeRTOS/: croutine.c list.c queue.c tasks.c
    FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
    ./: FreeRTOSConfig.h
    FreeRTOS/portable/MemMang/: heap_2.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group lwIP
    lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    lwip/ports/stellaris/include/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
    lwip/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    lwip/src/netif/: etharp.c
    lwip/ports/stellaris/netif/: ETHIsr.c LWIPStack.c
    lwip/ports/stellaris/include/netif/: ETHIsr.h LWIPStack.h stellarisif.h
    lwip/ports/stellaris/: perf.c sys_arch.c
  group MODBUS
    port/: drvserial.c drvserial.h mbmconfig.h mbport.h mbportevent.c mbportother.c mbportserial.c mbporttcp.c mbporttimer.c
    ../../mbslave/include/common/: mbframe.h mbportlayer.h
    ../../mbmaster/include/common/: mbframe.h mbportlayer.h mbtypes.h mbutils.h
    ../../mbmaster/: mbm.c
    ../../mbmaster/include/: mbm.h
    ../../mbmaster/ascii/: mbmascii.c mbmascii.h
    ../../mbmaster/rtu/: mbmcrc.c mbmcrc.h mbmrtu.c mbmrtu.h
    ../../mbmaster/functions/: mbmfunccoils.c mbmfuncdisc.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c
    ../../mbmaster/include/internal/: mbmi.h mbmiconfig.h mbmiframe.h
    ../../mbmaster/tcp/: mbmtcp.c mbmtcp.h
    ../../mbmaster/common/: mbutils.c
