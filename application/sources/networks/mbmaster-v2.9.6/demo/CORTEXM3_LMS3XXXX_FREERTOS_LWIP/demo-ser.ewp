# IAR project demo-ser.ewp, settings and files
configuration Debug - LM3S818 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S818 TexasInstruments LM3S818
  ICCARM.CCDefines: UART_BUFFERED; PART_LM3S818
  ICCARM.CCIncludePath2: $PROJ_DIR$; port; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM3; ..\..\mbmaster\include; Stellarisware
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: IARAS
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: demo-ser.srec
  ILINK.IlinkOutputFile: demo-ser.out
  ILINK.IlinkIcfFile: ewarm\interrupts-lm3s818.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug - LM3S6965 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: UART_BUFFERED; PART_LM3S6965
  group (top)
    ./: demo-serial.c
    ewarm/: startup_ewarm.c
  group DriverLib
    Stellarisware/driverlib/ewarm/: driverlib.a
    Stellarisware/driverlib/: gpio.h
    Stellarisware/utils/: uartstdio.c uartstdio.h
  group FreeRTOS
    FreeRTOS/: croutine.c list.c queue.c tasks.c
    ./: FreeRTOSConfig.h
    FreeRTOS/portable/MemMang/: heap_2.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group MODBUS
    port/: drvserial.c drvserial.h mbmconfig.h mbport.h mbportevent.c mbportother.c mbportserial.c mbporttimer.c
    ../../mbslave/include/common/: mbframe.h mbportlayer.h
    ../../mbmaster/include/common/: mbframe.h mbportlayer.h mbtypes.h mbutils.h
    ../../mbmaster/: mbm.c
    ../../mbmaster/include/: mbm.h
    ../../mbmaster/ascii/: mbmascii.c mbmascii.h
    ../../mbmaster/rtu/: mbmcrc.c mbmcrc.h mbmrtu.c mbmrtu.h
    ../../mbmaster/functions/: mbmfunccoils.c mbmfuncdisc.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c
    ../../mbmaster/include/internal/: mbmi.h mbmiconfig.h mbmiframe.h
    ../../mbmaster/tcp/: mbmtcp.c mbmtcp.h
    ../../mbmaster/common/: mbutils.c
